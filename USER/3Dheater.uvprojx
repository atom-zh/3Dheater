# Keil uVision project 3Dheater.uvprojx, settings and files
target 3Dheater (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 3Dheater +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TEMP;..\HARDWARE\RTC;..\HARDWARE\OLED;..\HARDWARE\WEIGHT;..\HARDWARE\BSP;..\HARDWARE\HUMIDITY;..\HARDWARE\EXTI;..\STM32F10x_FWLib\inc;..\HARDWARE\APP;..\HARDWARE\FAN;..\HARDWARE\HEATING
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/WEIGHT/: weight.c
    ../HARDWARE/TEMP/: temp.c
    ../HARDWARE/BSP/: BSP_Cfg.c
    ../HARDWARE/HUMIDITY/: humidity.c
    ../HARDWARE/APP/: menu.c
    ../HARDWARE/FAN/: fan.c
    ../HARDWARE/HEATING/: heating.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_exti.c
  group README
    ../: CHANGELOG.txt
